# Keil uVision project project.uvprojx, settings and files
target flash (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\uCOS-II\Source;..\User\app;..\User\bsp;..\uCOS-II\uC-CPU\ARM-Cortex-M3\RealView;..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\User\bsp\usart;..\User\bsp\spi;..\User\bsp\led;..\User\boards;..\User\hal;..\User\helpers;..\User\tmc;..\User\TMC5130;..\User\hal\Startrampe\tmc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../User/app/: app_cfg.h includes.h os_cfg.h stm32f10x_it.c cpu_cfg.h lib_cfg.h app_hooks.c main.c user.c
  group BSP
    ../User/bsp/: bsp.c
    ../User/bsp/usart/: bsp_usart1.c
    ../User/bsp/spi/: bsp_spi_flash.c
    ../User/bsp/led/: bsp_led.c
  group RVMDK
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_gpio.c stm32f10x_adc.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group uCOS-II/Source
    ../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS-II/Ports
    ../uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Lib
    ../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCOS-II/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group boards
    ../User/boards/: Board.c Rhino_standalone.c TMC5130_eval.c TMCDriver.c TMCMotionController.c
  group hal
    ../User/hal/Startrampe/tmc/: ADCs.c HAL.c IOMap.c IOs.c LEDs.c SPI.c SysTick.c Timer.c
  group tmc
    ../User/tmc/: BoardAssignment.c IdDetection_Startrampe.c IdEeprom.c StepDir.c TMCL.c VitalSignsMonitor.c
  group TMC5130
    ../User/TMC5130/: TMC5130.c
  group helpers
    ../User/helpers/: CRC.c
